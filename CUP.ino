/*квантологосы ЦПУ*/

//подключение библиотек
#include <SharpIR.h>
#include <Servo.h>// подключение библиотеки серво
#include "Adafruit_NeoPixel.h" //Подключение библиотеки для ленты

//настройка триггеров: кнопка и датчик ИК
#define butPin 3
#define ir 3
#define model 1080
SharpIR sharp(ir,model);
boolean butValue;//переменная кнопки
int sensorValue;//переменная датчика ИК

//пин сервы
#define servoPin 5
#define nuleServoDegree 170 //начальный угол поворота сервы
#define servoDegree 60//угол поворота сервопривода

Servo myservo;//переменная сервы

//настройка ленты противогаза
Adafruit_NeoPixel stripGas = Adafruit_NeoPixel(6, 6); // создаем переменную , где указываем кол-во диодов в ленте и управляющий пин

//настройка ленты лампы
Adafruit_NeoPixel stripLamp = Adafruit_NeoPixel(6, 7); // создаем переменную , где указываем кол-во диодов в ленте и управляющий пин

//настройка ленты дырокола
Adafruit_NeoPixel stripPunch = Adafruit_NeoPixel(15, 8); // создаем переменную , где указываем кол-во диодов в ленте и управляющий пин

void setup () {
  Serial.begin(9600);
//настройка пинов на вход
pinMode (butPin, INPUT_PULLUP);

  
  //настройка сервы на работу
  myservo.attach (servoPin);
  myservo.write (nuleServoDegree);//начальный угол сервы

  //настройка светодиодных лент
  stripGas.begin (); //инициализация ленты противогаза
  stripGas.setBrightness(255);//яркость светодиодов 
  stripLamp.begin (); //инициализация ленты лампы
  stripLamp.setBrightness(255);//яркость светодиодов 
  stripPunch.begin (); //инициализация ленты дырокола
  stripPunch.setBrightness(255);//яркость светодиодов 
}

void stripAllOn () { //функция включения ленты
  
//включение ленты для противогаза  
  for (int i = 0; i <6; i++) {
    stripGas.setPixelColor (i, 255, 0, 0);//красный цвет
  } 
  stripGas.show ();//показать на ленте

//включение ленты для лампы
for (int i = 0; i <6 ; i++) {
    stripLamp.setPixelColor (i, 255, 70, 0);//желтый цвет
  } 
  stripLamp.show ();//показать на ленте

//включение ленты для дырокола
for (int i = 0; i < 16 ; i++) {
    stripPunch.setPixelColor (i, 0, 150, 50);//зеленый цвет
    delay (200);
  } 
  stripPunch.show ();//показать на ленте
}

void stripAllOff() { //функция выключения ленты
  
//включение ленты для противогаза  
  for (int i = 0; i <6 ; i++) {
    stripGas.setPixelColor (i, 0, 0, 0);//выключение
  } 
  stripGas.show ();//показать на ленте

//включение ленты для лампы
for (int i = 0; i <6 ; i++) {
    stripLamp.setPixelColor (i, 0, 0, 0);//выключить
  } 
  stripLamp.show ();//показать на ленте

//включение ленты для дырокола
for (int i = 0; i <16 ; i++) {
    stripPunch.setPixelColor (i, 0, 0, 0);//выключить
  } 
  stripPunch.show ();//показать на ленте
}
void loop() {
  
  delay(100);   
butValue = digitalRead (butPin);//присваиваем переменной значение с кнопки
int dist = sharp.distance();//присваиваем переменной значение с ИК датчика

Serial.print ("butValue");
Serial.println (butValue);
Serial.print ("sensorValue");
Serial.println (dist);

if (butValue == 0 /*|| dist < 15*/ ) {//если одно из условий выполняется, то...
  stripAllOn ();
  for(int a = 0; a < 5; a++) {
    myservo.write(servoDegree);//поворачиваем серво на 60 градусов
    delay (500);
    myservo.write (nuleServoDegree);
    delay (500);
  }
  delay(5000); 
  for(int a = 0; a < 5; a++) {
    myservo.write(servoDegree);//поворачиваем серво на 60 градусов
    delay (500);
    myservo.write (nuleServoDegree);
    delay (500);
  }
}else{
  stripAllOff();
}
}
